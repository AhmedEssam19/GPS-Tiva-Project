# Keil uVision project GpsProject.uvproj, settings and files
target PeriodicSysTickInts (ARM-ADS)
  device: LM4F120H5QR Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: PeriodicSysTickInts
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c misc: --C99
  c include: ..;..\..\..;.\includes;.\includes\Delays
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: startup.s GpsProject_main.c
    ./includes/Delays/: Delays.c
    ./includes/UART/: UART_5.c UART_0.c
    ./includes/double_to_string/: DoubleToString.c
    ./includes/LEDs/: LEDs.c
    ./includes/GPS_Calculations/: GPS_Calculations.c
    ./includes/Point/: Point.c
    ./includes/LCD/: config_LCD.c display.c man_string.c timer.c
